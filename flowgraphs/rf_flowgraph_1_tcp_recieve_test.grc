options:
  parameters:
    author: derplime
    generate_options: qt_gui
    id: rf_flowgraph_1_tcp_recieve_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: uhd_bw
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: uhd_center_freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 192.168.1.5
    port: '2000'
    server: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: uhd_bw
    fc: uhd_center_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [network_tcp_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
