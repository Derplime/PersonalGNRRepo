options:
  parameters:
    author: derplime
    generate_options: qt_gui
    id: rf_flowgraph_1
    output_language: python
    title: Loopback Over TCP 1
  states: {}

blocks:
- name: signal_src_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: signal_src_samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: uhd_bw
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: uhd_center_freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: uhd_gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: uhd_sample_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: signal_src_freq
    offset: '0'
    phase: '0'
    samp_rate: signal_src_samp_rate
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: Use lower than 1M sample rate with N200
  states: {}
- name: note_1
  id: note
  parameters:
    note: There is a TCP Sink Block to potentially send stream over TCP.
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: uhd_bw
    center_freq0: uhd_center_freq
    dev_addr: '"addr=192.168.1.6"'
    dev_args: '""'
    gain0: uhd_gain
    samp_rate: uhd_sample_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: uhd_bw
    center_freq0: uhd_center_freq
    dev_addr: '"addr=192.168.1.6"'
    dev_args: '""'
    gain0: uhd_gain
    samp_rate: uhd_sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
